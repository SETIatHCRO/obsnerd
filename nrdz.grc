options:
  parameters:
    author: wfarah
    generate_options: qt_gui
    id: nrdz
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 512e6
  states: {}
- name: nfft
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: nfft2
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: tune
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ddeboer/nrdz
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/ddeboer/nrdzc
    type: complex
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(0.2*samp_rate/nfft)
    type: float
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '1'
    type: float
    vlen: nfft
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '30'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: nfft
    x_start: '-samp_rate/2+1.575e9'
    x_step: samp_rate/nfft
    ymax: '60'
    ymin: '-20'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 122.88e6
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.uhd_usrp_source.set_time_next_pps(uhd.time_spec(int(time.time())+1))
      self.uhd_usrp_source.set_lo_export_enabled(True, "lo1", 0)
      self.uhd_usrp_source.set_rx_lo_dist(True, "LO_OUT_0")
      self.uhd_usrp_source.set_rx_lo_dist(True, "LO_OUT_1")
      self.uhd_usrp_source.set_lo_source("external", "lo1", 0)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 1)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 2)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 3)
      time.sleep(1)
    section: main_after_init
  states: {}
- name: src_name
  id: parameter
  parameters:
    type: str
    value: '''unknown_source'''
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    ant2: RX2
    ant3: RX2
    center_freq0: fc
    center_freq1: fc
    center_freq2: fc
    center_freq3: fc
    clock_source0: external
    clock_source1: external
    dev_addr: '"addr0=10.11.1.20,addr1=10.11.1.22"'
    dev_args: '""'
    gain0: gaindB
    gain1: gaindB
    gain2: gaindB
    gain3: gaindB
    nchan: '4'
    num_mboards: '2'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_vector_sink_f_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source, '0', blocks_file_sink_0_0, '0']
- [uhd_usrp_source, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source, '1', blocks_null_sink_0, '1']
- [uhd_usrp_source, '2', blocks_null_sink_0, '0']
- [uhd_usrp_source, '3', blocks_null_sink_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
